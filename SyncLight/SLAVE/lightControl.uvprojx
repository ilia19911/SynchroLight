# Keil uVision project lightControl.uvprojx, settings and files
target synchroLight_slave_debug (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lightControl_slave +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, HSE_VALUE=16000000, STM32F10X_MD
  c include: .\;.\CMSIS;.\Hdr;..\commonLibs\StdPeriph\inc;..\commonLibs\unilib;..\commonLibs\unilib\external_devices;..\commonLibs\unilib\file_io;..\commonLibs\unilib\mcs;..\commonLibs\unilib\mcs\arm_cm3;..\commonLibs\unilib\mcs\stm32;..\commonLibs\unilib\crc;..\commonLibs\fatfs;..\commonLibs\unilib\ic_drivers;..\commonLibs\leds;..\commonLibs
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group StdPeriph
    ../commonLibs/StdPeriph/src/: misc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c
  group unilib
    ../commonLibs/StdPeriph/src/: stm32f10x_iwdg.c stm32f10x_adc.c
    ../commonLibs/unilib/: endianes.c fifo.c dprintf.c spi_bitbang.c
    ../commonLibs/unilib/external_devices/: sx1276_transc.c
    ../commonLibs/unilib/mcs/arm_cm3/: delay.c
    ../commonLibs/unilib/mcs/stm32/: crc32.c rcc.c randomizer.c uart.c adclib.c systick_timer.c uni_flash.c uni_eeprom.c
    ../commonLibs/unilib/ic_drivers/: at25db321_fileStrorage.c at25df.c
  group SRC
    ./Src/: main.c low_level0.c it.c fileTransfer.c
    ../commonLibs/: rf_parser.c display_kingbright.c
  group fatfs
    ../commonLibs/fatfs/: ff.c fatfs_diskio_sdcard_spi.c
  group leds
    ../commonLibs/leds/: effect_processor.c led_maping.c player.c scen_memory.c ws2812b.c
target synchroLight_slave_release (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: lightControl_slave +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, HSE_VALUE=16000000, STM32F10X_MD, NDEBUG
  c include: as above
  memory RVCT4: ROM 0x8002000 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x5000
