# Keil uVision project bootloader.uvprojx, settings and files
target bootloader_master (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: azurit_boot_master +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER, HSE_VALUE=16000000, BOOTLOADER_MODULE_UART, PLATE_MASTER
  c include: .\Hdr;.\CMSIS;.\StdPeriph\inc;.\unilib;.\unilib\mcs\arm_cm3;.\unilib\mcs\stm32;.\unilib\external_devices;.\unilib\crc;.\unilib\proto;.\unilib\ic_drivers;.\aes_crypt
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group StdPeriph
    ./StdPeriph/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
  group Unilib
    ./unilib/: fifo.c endianes.c
    ./unilib/mcs/stm32/: rcc.c systick_timer.c uart.c crc32.c
    ./unilib/mcs/arm_cm3/: delay.c
    ./unilib/external_devices/: sx1276_transc.c
    ./unilib/crc/: crc8.c
  group UserSrc
    ./Src/: main.c low_level0.c
    ./Hdr/: bootconf.h
    ./src/: bootloader.c
    ./hdr/: bootloader.h
target bootloader_slave (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: azurit_boot_slave +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER, HSE_VALUE=16000000, BOOTLOADER_MODULE_SX1276, PLATE_SLAVE
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
